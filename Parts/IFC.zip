Properties of the parts of a building model (IFC2X3)

# File
Description: Unknown
File name: ClGray_4211536_AVV
Time: 2025-07-21T23:50:48+02:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v19.4
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
